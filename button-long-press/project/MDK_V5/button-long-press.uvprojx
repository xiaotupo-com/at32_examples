# Keil uVision project button-long-press.uvprojx, settings and files
target button-long-press (6160000::V6.16::ARMCLANG)
  device: -AT32F437ZGT7 ArteryTek
  pack: ArteryTek.AT32F435_437_DFP.2.2.1
  cpu: IRAM(0x20000000,0x18000000) IROM(0x08000000,0x40000000F0000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: button-long-press +hex
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: AT32F437ZGT7,USE_STDPERIPH_DRIVER
  c include: ..\..\libraries\drivers\inc;..\..\libraries\cmsis\cm4\core_support;..\..\libraries\cmsis\cm4\device_support;..\inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x60000
  group user
    ../src/: at32f435_437_int.c at32f435_437_wk_config.c main.c wk_system.c wk_usart.c wk_gpio.c wk_exint.c sf_utils.c sf_buzzer.c sf_system.c
  group firmware
    ../../libraries/drivers/src/: at32f435_437_crm.c at32f435_437_gpio.c at32f435_437_usart.c at32f435_437_pwc.c at32f435_437_debug.c at32f435_437_flash.c at32f435_437_exint.c at32f435_437_misc.c at32f435_437_scfg.c
  group cmsis
    ./: startup_at32f435_437.s
    ../../libraries/cmsis/cm4/device_support/: system_at32f435_437.c
