# Keil uVision project led_blink_lcd1602_ec11.uvprojx, settings and files
target led_blink_printf_ec11 (6160000::V6.16::ARMCLANG)
  device: -AT32F437ZGT7 ArteryTek
  pack: ArteryTek.AT32F435_437_DFP.2.2.1
  cpu: IRAM(0x20000000,0x60000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: led_blink_printf_ec11 +hex
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=9 wLevel=3
  c define: AT32F437ZGT7,USE_STDPERIPH_DRIVER
  c include: ..\libraries\drivers\inc;..\libraries\cmsis\cm4\core_support;..\libraries\cmsis\cm4\device_support;..\inc;..\middlewares\freertos\source\include;..\apps\include;..\middlewares\freertos\source\portable\GCC\ARM_CM4F;..\apps\led;..\apps\v_application_tick_hook;..\apps\gpio_init;..\apps\freertos_app;..\apps\lcd1602;..\apps\us_delay;..\apps\buzzer;..\apps\key
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x60000
  group user
    ../src/: at32f435_437_int.c at32f435_437_clock.c main.cpp nvic_config.c uart_config.c printf_config.c
  group firmware
    ../libraries/drivers/src/: at32f435_437_acc.c at32f435_437_adc.c at32f435_437_can.c at32f435_437_crc.c at32f435_437_crm.c at32f435_437_dac.c at32f435_437_debug.c at32f435_437_dma.c at32f435_437_dvp.c at32f435_437_edma.c at32f435_437_emac.c at32f435_437_ertc.c at32f435_437_exint.c at32f435_437_flash.c at32f435_437_gpio.c at32f435_437_i2c.c at32f435_437_misc.c at32f435_437_pwc.c at32f435_437_qspi.c at32f435_437_scfg.c at32f435_437_sdio.c at32f435_437_spi.c at32f435_437_tmr.c at32f435_437_usart.c at32f435_437_usb.c at32f435_437_wdt.c at32f435_437_wwdt.c at32f435_437_xmc.c
  group cmsis
    ../libraries/cmsis/cm4/device_support/: system_at32f435_437.c
    ../libraries/cmsis/cm4/device_support/startup/mdk/: startup_at32f435_437.s
  group readme
    ../: readme.txt
  group freertos
    ../middlewares/freertos/source/: list.c queue.c tasks.c
    ../middlewares/freertos/source/portable/memmang/: heap_4.c
    ../middlewares/freertos/source/portable/GCC/ARM_CM4F/: port.c
  group apps
    ../apps/led/: led.cpp
    ../apps/gpio_init/: gpio_init.cpp
    ../apps/v_application_tick_hook/: v_application_tick_hook.cpp
    ../apps/freertos_app/: freertos_app.cpp
    ../apps/lcd1602/: lcd1602.cpp
    ../apps/us_delay/: us_delay.c
    ../apps/buzzer/: buzzer.cpp
    ../apps/key/: key.cpp
