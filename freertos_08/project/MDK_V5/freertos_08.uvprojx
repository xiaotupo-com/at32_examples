# Keil uVision project freertos_08.uvprojx, settings and files
target freertos_08 (6160000::V6.16::ARMCLANG)
  device: -AT32F437ZGT7 ArteryTek
  pack: ArteryTek.AT32F435_437_DFP.2.2.1
  cpu: IRAM(0x20000000,0x60000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: freertos_08 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: AT32F437ZGT7,USE_STDPERIPH_DRIVER
  c include: ..\..\libraries\drivers\inc;..\..\libraries\cmsis\cm4\core_support;..\..\libraries\cmsis\cm4\device_support;..\inc;..\..\app\bsp\include;..\..\app\utils;../../middlewares/freertos/source/include;../../middlewares/freertos/source/portable/memmang;../../middlewares/freertos/source/portable/GCC/ARM_CM4F
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x60000
  group user
    ../src/: at32f435_437_int.c at32f435_437_wk_config.c main.c wk_system.c freertos_app.c include_port.c wk_spi.c wk_usart.c wk_dma.c wk_gpio.c
  group firmware
    ../../libraries/drivers/src/: at32f435_437_crm.c at32f435_437_gpio.c at32f435_437_usart.c at32f435_437_pwc.c at32f435_437_spi.c at32f435_437_dma.c at32f435_437_debug.c at32f435_437_flash.c at32f435_437_misc.c
  group cmsis
    ./: startup_at32f435_437.s
    ../../libraries/cmsis/cm4/device_support/: system_at32f435_437.c
  group apps/bsp
    ../../app/bsp/src/: lcd_blk.c lcd_demo.c lcd_write_pixel_data.c spi_api.c st7789.c st7789_config.c
  group middlewares/freertos
    ../../middlewares/freertos/source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c stream_buffer.c
    ../../middlewares/freertos/source/portable/memmang/: heap_4.c
